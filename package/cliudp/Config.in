## package/measure/Config.in
```kconfig
config BR2_PACKAGE_MEASURE
	bool "measure" 
	help
		Lecteur pour le capteur Adafruit
```
